options:
  parameters:
    author: Isaac Tupac
    generate_options: qt_gui
    id: Prueb_2canales_10MHz
    output_language: python
    title: Prueba 2 canales
  states: {}

blocks:
- name: Lat_ind
  id: variable
  parameters:
    value: gpsdo.Lat_ind
  states: {}
- name: Latitud
  id: variable
  parameters:
    value: gpsdo.Latitud
  states: {}
- name: Long_ind
  id: variable
  parameters:
    value: gpsdo.Long_ind
  states: {}
- name: Longitud
  id: variable
  parameters:
    value: gpsdo.Longitud
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '100'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: (1,)*int(100)
  states: {}
- name: freq_almac
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: freq_centr
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: freq_centr_2
  id: variable
  parameters:
    value: 7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: Generator_ROJ_Generator_ROJ_0
  id: Generator_ROJ_Generator_ROJ
  parameters:
    Amplitud: '500e-3'
    Center_freq: freq_centr_2
    Fase_ipp: '0'
    Ipp: '20'
    Path_file: /home/soporte/Isaac/ProgrDemo/all_freq_list_10ms.txt
    Sample_rate: samp_rate
    Waveform: Seno
  states: {}
- name: Generator_ROJ_Generator_ROJ_0_0
  id: Generator_ROJ_Generator_ROJ
  parameters:
    Amplitud: '500e-3'
    Center_freq: freq_centr
    Fase_ipp: '0'
    Ipp: '20'
    Path_file: /home/soporte/Isaac/ProgrDemo/all_freq_list_10ms.txt
    Sample_rate: samp_rate
    Waveform: Seno
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_2_0
  id: blocks_throttle
  parameters:
    samples_per_second: freq_almac
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_2_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: freq_almac
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_2_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: '2'
    taps: (1,1,1,1,1,1)
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: '2'
    taps: (1,1,1,1,1,1)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: filter_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: filter_taps
    type: ccc
  states: {}
- name: gpsdo
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      f=open("/home/soporte/Isaac/AdquisIonosOblic/gpsdo.txt","r")
      Latitud=float(f.readline())
      Lat_ind=f.readline()
      Longitud=float(f.readline())
      Long_ind=f.readline()
      f.close
      #print("LA LISTA ES:",ListFile)
  states: {}
- name: gr_digital_rf_digital_rf_channel_sink_0
  id: gr_digital_rf_digital_rf_channel_sink
  parameters:
    center_freqs: ''
    checksum: 'False'
    compression_level: '8'
    debug: 'False'
    dir: /home/soporte/Isaac/AdquIonoSDR/DataAdquirida/2Canales/Canal0
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{"samp_rate":samp_rate,"bandwidth":samp_rate,"decimation":decimation,"storFreq":freq_almac,"filterTaps":filter_taps,"centerFreq":freq_centr_2,"Latitud":Latitud,"Lat_ind":Lat_ind,"Longitud":Longitud,"Long_ind":Long_ind}'
    min_chunksize: '0'
    sample_rate_denominator: '1'
    sample_rate_numerator: freq_almac
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    uuid: ''
    vlen: '1'
  states: {}
- name: gr_digital_rf_digital_rf_channel_sink_0_0
  id: gr_digital_rf_digital_rf_channel_sink
  parameters:
    center_freqs: ''
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    dir: /home/soporte/Isaac/AdquIonoSDR/DataAdquirida/2Canales/Canal1
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{"samp_rate":samp_rate,"bandwidth":samp_rate,"decimation":decimation,"storFreq":freq_almac,"filterTaps":filter_taps,"centerFreq":freq_centr,"Latitud":Latitud,"Lat_ind":Lat_ind,"Longitud":Longitud,"Long_ind":Long_ind}'
    min_chunksize: '0'
    sample_rate_denominator: '1'
    sample_rate_numerator: freq_almac
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    uuid: ''
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_time_sink_x_1_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    marker2: '0'
    name: '"canal 5"'
    size: '1024'
    srate: samp_rate
    style1: '3'
    style2: '3'
    type: complex
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      nmea=self.uhd_usrp_source_0.get_mboard_sensor("gps_gpgga").to_pp_string() #Adquiere la hora gps local
      print('El valor del  nmea completo es:',nmea)
      valor_posic=nmea[18:26]
      valor_posic=float(valor_posic)
      #print("El tipo de valor_posic es:",type(valor_int))
      print('El valor UTC de:l inicio del programa es:',valor_posic)
      valor_latitud=nmea[28:37]
      print('El valor de la latitud es:',valor_latitud)
      latitud_indica=nmea[38]
      print('El valor del indicador de la latitud es:',latitud_indica)
      valor_longitud=nmea[40:50]
      print('El valor de la longitud es:',valor_longitud)
      longitud_indica=nmea[51]
      print('El valor del indicador de la longitud es:',longitud_indica)
      f=open("/home/soporte/Isaac/AdquisIonosOblic/gpsdo.txt","w")
      f.writelines([valor_latitud+"\n",latitud_indica+"\n",valor_longitud+"\n",longitud_indica+"\n"])
    priority: ''
    section: main_after_init
  states: {}
- name: snippet_2_0_1_0_0_0
  id: snippet
  parameters:
    code: |-
      gps_time=uhd.time_spec_t(self.uhd_usrp_source_0.get_mboard_sensor("gps_time").to_int()+1.0) #Adquiere la hora gps local
      print('El valor de  gps_time es:',gps_time)
      self.uhd_usrp_source_0.set_time_next_pps(gps_time); # setea el tiempo gps en el siguiente PPS

      Full_second=gps_time.get_full_secs() #Adquiere el epoch en seg.

      UTC_time= datetime.utcfromtimestamp(Full_second) # Adquiere el tiempo en formato de UTC

      year=int(UTC_time.strftime("%Y"))
      print('El valor de  year es:',year)
      month=int(UTC_time.strftime("%m"))
      print('El valor de  month es:',month)
      day=int(UTC_time.strftime("%d"))
      print('El valor de  day es:',day)
      hour=int(UTC_time.strftime("%H"))
      print('El valor de  hour es:',hour)
      minute=int(UTC_time.strftime("%M"))
      print('El valor de  minute es:',minute)
      second=int(UTC_time.strftime("%S"))
      print('El valor de  second es:',second)

      if(hour>=5):
       dayN=day
       monthF=month

      if (hour==0):
       hour=24
       dayN=(day-1)
       monthF=month
      elif (hour==1):
       hour=25
       dayN=(day-1)
       monthF=month
      elif (hour==2):
       hour=26
       dayN=(day-1)
       monthF=month
      elif (hour==3):
       hour=27
       dayN=(day-1)
       monthF=month
      elif (hour==4):
       hour=28
       dayN=(day-1)
       monthF=month

      if (((month==2) or (month==4) or (month==6) or (month==8) or (month==9) or (month==11) or (month==1)) and (dayN==0)):
       dayN=31
       monthF=month-1
      elif (((month==3) or (month==5) or (month==7) or (month==10) or (month==12)) and (dayN==0)):
       if(month==3):
        dayN=28 
        monthF=month-1
        if(year%4==0): #bisiesto
         dayN=29
         monthF=month-1
       else:
        dayN=30 
        monthF=month-1

      print('El valor de  dayN es:',dayN)
      print('El valor de monthF es:',monthF)
      print('El valor de  hour -5 es:',hour-5)
      #date_time = datetime(year, monthF, dayN, (hour-5), (minute+1), 4) # Se resta 5h para ponerlo en hora local (gps), se suma 1seg porque el crontab fue corrido un seg antes
      date_time = datetime(year, monthF, dayN, (hour-5), (minute+1), 5)

      unix_time=time.mktime(date_time.timetuple())# epoch time en el cual comenzara la adquisicion por USRP
      print('El valor de unix_times es:',unix_time)
      # Poner 4s+960ms o 4s+1.0s
      #self.uhd_usrp_source_0.set_start_time(uhd.time_spec_t(unix_time,1.120))
      #self.uhd_usrp_source_0.set_start_time(uhd.time_spec_t(unix_time,0.960))
      self.uhd_usrp_source_0.set_start_time(uhd.time_spec_t(unix_time)) #Para 4seg y 5 seg
    priority: ''
    section: main_after_init
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: freq_centr_2
    center_freq1: freq_centr
    clock_source0: gpsdo
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: '"A:B A:A"'
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [Generator_ROJ_Generator_ROJ_0, '0', blocks_throttle_0_0_0, '0']
- [Generator_ROJ_Generator_ROJ_0_0, '0', blocks_throttle_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', fir_filter_xxx_0_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_throttle_0_0_0, '0', qtgui_time_sink_x_1_2, '0']
- [blocks_throttle_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [blocks_throttle_0_0_0_2, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_throttle_0_0_0_2_0, '0', gr_digital_rf_digital_rf_channel_sink_0, '0']
- [blocks_throttle_0_0_0_2_0_0, '0', gr_digital_rf_digital_rf_channel_sink_0_0, '0']
- [blocks_throttle_0_0_0_2_1, '0', blocks_multiply_xx_0_0_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_throttle_0_0_0_2_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_throttle_0_0_0_2_0_0, '0']
- [fir_filter_xxx_0_0, '0', fft_filter_xxx_0, '0']
- [fir_filter_xxx_0_0_0, '0', fft_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle_0_0_0_2, '0']
- [uhd_usrp_source_0, '1', blocks_throttle_0_0_0_2_1, '0']

metadata:
  file_format: 1
